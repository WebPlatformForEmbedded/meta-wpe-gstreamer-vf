#FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

# SRC_URI += "file://0001-Initial-gstreamer-wpe-support.patch"
