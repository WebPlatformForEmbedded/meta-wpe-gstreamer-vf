FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-Initial-support-for-wpe-gstreamer.patch"

